# Keil uVision project PWM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: PWM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\drive\inc
  group user
    ./: STARTUP.A51 PWM.c
  group drive
    ../drive/src/: 1602.c
