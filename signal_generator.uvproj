# Keil uVision project signal_generator.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: signal_generator +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\drive\inc
  group user
    ./: STARTUP.A51
    ./user/: mian.c
